# Keil uVision project Drone.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Drone
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM
  c include: ..\src
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: main.c mat.c mat.h mpu.c mpu.h pid.c pid.h rx.c rx.h sonar.c time.c time.h buzzer.h buzzer.c sonar.h i2c_1.h uart_1.c i2c_1.c uart_1.h pwm_1.c pwm_1.h Lights.c Lights.h
  group inc
    ./inc/: asmdefs.h hw_adc.h hw_aes.h hw_can.h hw_ccm.h hw_comp.h hw_des.h hw_eeprom.h hw_emac.h hw_epi.h hw_fan.h hw_flash.h hw_gpio.h hw_hibernate.h hw_i2c.h hw_ints.h hw_lcd.h hw_memmap.h hw_nvic.h hw_onewire.h hw_pwm.h hw_qei.h hw_shamd5.h hw_ssi.h hw_sysctl.h hw_sysexc.h hw_timer.h hw_types.h hw_uart.h hw_udma.h hw_usb.h hw_watchdog.h sc4c1290kcpdt.h sc4c1294ncpdt.h sc4ca294ncpdt.h sc4cb297nczad.h sc4cc231e6pm.h sc4ce93xh6pm.h sc4ce290ncpz.h tm4c123ae6pm.h tm4c123ah6pm.h tm4c123be6pm.h tm4c123be6pz.h tm4c123bh6pge.h tm4c123bh6pm.h tm4c123bh6pz.h tm4c123bh6zrb.h tm4c123fe6pm.h tm4c123fh6pm.h tm4c123ge6pm.h tm4c123ge6pz.h tm4c123gh6pge.h tm4c123gh6pm.h tm4c123gh6pz.h tm4c123gh6zrb.h tm4c123gh6zxr.h tm4c129cncpdt.h tm4c129cnczad.h tm4c129dncpdt.h tm4c129dnczad.h tm4c129ekcpdt.h tm4c129encpdt.h tm4c129enczad.h tm4c129lnczad.h tm4c129xkczad.h tm4c129xnczad.h tm4c1230c3pm.h tm4c1230d5pm.h tm4c1230e6pm.h tm4c1230h6pm.h tm4c1231c3pm.h tm4c1231d5pm.h tm4c1231d5pz.h tm4c1231e6pm.h tm4c1231e6pz.h tm4c1231h6pge.h tm4c1231h6pm.h tm4c1231h6pz.h tm4c1232c3pm.h tm4c1232d5pm.h tm4c1232e6pm.h tm4c1232h6pm.h tm4c1233c3pm.h tm4c1233d5pm.h tm4c1233d5pz.h tm4c1233e6pm.h tm4c1233e6pz.h tm4c1233h6pge.h tm4c1233h6pm.h tm4c1233h6pz.h tm4c1236d5pm.h tm4c1236e6pm.h tm4c1236h6pm.h tm4c1237d5pm.h tm4c1237d5pz.h tm4c1237e6pm.h tm4c1237e6pz.h tm4c1237h6pge.h tm4c1237h6pm.h tm4c1237h6pz.h tm4c1290ncpdt.h tm4c1290nczad.h tm4c1292ncpdt.h tm4c1292nczad.h tm4c1294kcpdt.h tm4c1294ncpdt.h tm4c1294nczad.h tm4c1297nczad.h tm4c1299kczad.h tm4c1299nczad.h
  group driverlib
    ./driverlib/: adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h interrupt.h onewire.h pin_map.h qei.h readme.txt rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h udma.h usb.h watchdog.h adc.c aes.c can.c comp.c cpu.c crc.c des.c eeprom.c emac.c epi.c flash.c fpu.c gpio.c hibernate.c interrupt.c lcd.c onewire.c qei.c shamd5.c ssi.c sw_crc.c sysctl.c sysexc.c systick.c timer.c udma.c usb.c watchdog.c uart.h uart.c i2c.c i2c.h pwm.c pwm.h
  group utils
    ./driverlib/: adc.h aes.h can.h comp.h cpu.h crc.h debug.h des.h eeprom.h emac.h epi.h flash.h fpu.h gpio.h hibernate.h interrupt.h lcd.h onewire.h pin_map.h qei.h readme.txt rom.h rom_map.h rtos_bindings.h shamd5.h ssi.h sw_crc.h sysctl.h sysexc.h systick.h timer.h udma.h usb.h watchdog.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.0.1
